options:
  parameters:
    author: Martin Braun
    generate_options: qt_gui
    id: esprit_freqest
    output_language: python
    title: ESPRIT Frequency Estimator
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Sinusoid 1 amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '.7'
  states: {}
- name: amp2
  id: variable_qtgui_range
  parameters:
    label: Sinusoid 2 amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '.5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency 1
    orient: Qt.Horizontal
    start: '-.5'
    step: '.001'
    stop: '.5'
    value: '.2'
  states: {}
- name: freq2
  id: variable_qtgui_range
  parameters:
    label: Frequency 2
    orient: Qt.Horizontal
    start: '-.5'
    step: '.001'
    stop: '.5'
    value: '.1'
  states: {}
- name: num_sinusoids
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samps_per_R
  id: variable
  parameters:
    value: '512'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp2
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      We normalize by 2*pi because our
      original inputs were also normalized that way
    const: '[.5/math.pi,]*num_sinusoids'
    type: float
    vlen: '2'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      This groups together all
      samples per estimate
    num_items: samps_per_R
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 100e3
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-50'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '.2'
    graph_type: qtgui.NUM_GRAPH_NONE
    nconnections: '2'
    type: float
    update_time: '.5'
  states: {}
- name: specest_esprit_vcf_0
  id: specest_esprit_vcf
  parameters:
    m: '8'
    n: num_sinusoids
    nsamples: samps_per_R
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_stream_to_vector_0, '0', specest_esprit_vcf_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_number_sink_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_number_sink_0, '1']
- [specest_esprit_vcf_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
