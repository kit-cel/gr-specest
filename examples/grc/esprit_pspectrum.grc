options:
  parameters:
    author: Martin Braun
    generate_options: qt_gui
    id: esprit_pseudospectrum
    output_language: python
    title: ESPRIT Pseudospectrum
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Sinusoid amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '.4'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-.5'
    step: '.001'
    stop: '.5'
    value: '.2'
  states: {}
- name: pspec_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: freq
    offset: '0'
    samp_rate: '1'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: pspec_len
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 100e3
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: Pseudospectrum
    name: '"ESPRIT Pseudospectrum"'
    showports: 'True'
    vlen: pspec_len
    x_axis_label: '"Normalized Frequency"'
    x_start: '-.5'
    x_step: 1.0/pspec_len
    x_units: '"f"'
    y_axis_label: '"Power Pseudo-Spectrum"'
    y_units: '"dB"'
    ymax: '50'
    ymin: '-20'
  states: {}
- name: specest_esprit_0
  id: specest_esprit
  parameters:
    decimation: '1'
    m: '16'
    n: '1'
    nsamples: '128'
    pspectrum_len: pspec_len
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_throttle_0, '0', specest_esprit_0, '0']
- [specest_esprit_0, '0', blocks_nlog10_ff_0, '0']

metadata:
  file_format: 1
