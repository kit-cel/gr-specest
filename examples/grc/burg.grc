options:
  parameters:
    author: mbr0wn
    generate_options: qt_gui
    id: burg
    output_language: python
    title: Burg's Algorithm
  states: {}

blocks:
- name: ar_taps
  id: variable
  parameters:
    value: '[1, -1.372, 1.843, -1.238, .849]'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: fftpack.fftshift(abs(ssignal.freqz(1, ar_taps, fft_len, True)[1])) / 100
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: fftpack.fftshift(abs(ssignal.freqz(1, ar_taps, fft_len, True)[1]))
    vlen: fft_len
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: ar_taps
    fftaps: '[1]'
    oldstyle: 'False'
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from scipy import signal as ssignal
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from scipy import fftpack
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: Burg's Method
    label2: Filter Spectrum
    nconnections: '2'
    vlen: fft_len
    x_axis_label: Frequency
    x_start: '-samp_rate/2/1e6'
    x_step: samp_rate/fft_len/1e6
    x_units: MHz
    y_axis_label: Power Spectrum Density
    y_units: dB
    ymax: '40'
    ymin: '-40'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: Welch's Method
    label2: Filter Spectrum
    nconnections: '2'
    vlen: fft_len
    x_axis_label: Frequency
    x_start: '-samp_rate/2/1e6'
    x_step: samp_rate/fft_len/1e6
    x_units: MHz
    y_axis_label: Power Spectrum Density
    y_units: dB
    ymax: '40'
    ymin: '-40'
  states: {}
- name: specest_burg_0
  id: specest_burg
  parameters:
    blocklen: '256'
    decimation: '1'
    fftlen: fft_len
    fftshift: 'True'
    order: '6'
  states: {}
- name: specest_welch_0
  id: specest_welch
  parameters:
    beta: '6.76'
    fftlen: fft_len
    fftshift: 'True'
    malen: '8'
    overlap: '-1'
    wintype: firdes.WIN_BLACKMAN
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_nlog10_ff_0_0_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_throttle_0, '0', iir_filter_xxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_nlog10_ff_0_0_0_0, '0']
- [iir_filter_xxx_0, '0', specest_burg_0, '0']
- [iir_filter_xxx_0, '0', specest_welch_0, '0']
- [specest_burg_0, '0', blocks_nlog10_ff_0, '0']
- [specest_welch_0, '0', blocks_nlog10_ff_0_0, '0']

metadata:
  file_format: 1
