options:
  parameters:
    author: Martin Braun
    generate_options: qt_gui
    id: welch_demo
    output_language: python
    title: Welch's Method Demo
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fft_len_short
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '.2'
    comment: |-
      We generate a bunch of unrelated signals,
      including a noise source.
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 200e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_len_short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (0, 0, 1, 1)
    label1: PSD
    vlen: fft_len
    x_axis_label: Frequency (kHz)
    x_start: '-samp_rate/2/1000'
    x_step: samp_rate/fft_len/1000
    x_units: kHz
    y_axis_label: Power Spectrum Density
    y_units: dB
    ymax: '30'
    ymin: '-30'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (1, 1, 1, 1)
    label1: PSD
    vlen: fft_len
    x_axis_label: Frequency (kHz)
    x_start: '-samp_rate/2/1000'
    x_step: samp_rate/fft_len/1000
    x_units: kHz
    y_axis_label: Power Spectrum Density (Boxcar Window)
    y_units: dB
    ymax: '30'
    ymin: '-30'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (1, 0, 1, 1)
    label1: PSD
    vlen: fft_len
    x_axis_label: Frequency (kHz)
    x_start: '-samp_rate/2/1000'
    x_step: samp_rate/fft_len/1000
    x_units: kHz
    y_axis_label: Power Spectrum Density (Low Average)
    y_units: dB
    ymax: '30'
    ymin: '-30'
  states: {}
- name: qtgui_vector_sink_f_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (0, 1, 1, 1)
    label1: PSD
    vlen: fft_len_short
    x_axis_label: Frequency (kHz)
    x_start: '-samp_rate/2/1000'
    x_step: samp_rate/fft_len_short/1000
    x_units: kHz
    y_axis_label: Power Spectrum Density (Shorter FFT)
    y_units: dB
    ymax: '30'
    ymin: '-30'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: ccc
  states: {}
- name: specest_welch_0
  id: specest_welch
  parameters:
    beta: '6.76'
    fftlen: fft_len
    fftshift: 'True'
    malen: '32'
    overlap: '-1'
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: specest_welch_0_0
  id: specest_welch
  parameters:
    beta: '6.76'
    fftlen: fft_len
    fftshift: 'True'
    malen: '8'
    overlap: '-1'
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: specest_welch_0_1
  id: specest_welch
  parameters:
    beta: '6.76'
    fftlen: fft_len
    fftshift: 'True'
    malen: '8'
    overlap: '-1'
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: specest_welch_0_1_0
  id: specest_welch
  parameters:
    beta: '6.76'
    fftlen: fft_len_short
    fftshift: 'True'
    malen: '8'
    overlap: '-1'
    wintype: firdes.WIN_BLACKMAN
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_random_source_x_0, '0', digital_gmsk_mod_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', specest_welch_0, '0']
- [blocks_add_xx_0, '0', specest_welch_0_0, '0']
- [blocks_add_xx_0, '0', specest_welch_0_1, '0']
- [blocks_add_xx_0, '0', specest_welch_0_1_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_nlog10_ff_0_1_0, '0', qtgui_vector_sink_f_0_1_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [digital_gmsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_xx_0, '0']
- [specest_welch_0, '0', blocks_nlog10_ff_0, '0']
- [specest_welch_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [specest_welch_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [specest_welch_0_1_0, '0', blocks_nlog10_ff_0_1_0, '0']

metadata:
  file_format: 1
